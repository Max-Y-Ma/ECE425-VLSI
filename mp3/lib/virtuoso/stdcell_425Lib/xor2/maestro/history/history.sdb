<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Feb 28 09:35:50 2024</timestamp>
			<uuid>{118dfc30-8eb0-457a-82c2-f0d56465e1f9}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/maxma2/Documents/Coursework/ece425/mp3/lib/virtuoso/stdcell_425Lib/xor2/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/maxma2/Documents/Coursework/ece425/mp3/lib/virtuoso/stdcell_425Lib/xor2/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/maxma2/simulation/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/maxma2/simulation/results/maestro/ExplorerRun.0</simdir>
		</historyentry>
	</history>
</setupdb>
