<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Feb 25 14:17:59 2024</timestamp>
			<uuid>{fcdb2459-22a5-482c-b6f4-067fe90d4c8d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/maxma2/Documents/Coursework/ece425/mp3/lib/virtuoso/stdcell_425Lib/and2/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/maxma2/Documents/Coursework/ece425/mp3/lib/virtuoso/stdcell_425Lib/and2/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/maxma2/simulation/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/maxma2/simulation/results/maestro/ExplorerRun.0</simdir>
		</historyentry>
	</history>
</setupdb>
